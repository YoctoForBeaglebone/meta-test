IMAGE_INSTALL = "helloworld"
inherit core-image